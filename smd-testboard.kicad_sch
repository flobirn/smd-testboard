File: smd-testboard.kicad_sch (KiCad schematic)
At the start: 31 parts

Commit message: examples for transistors
Other:
- added sheet examples (examples.kicad_sch)
